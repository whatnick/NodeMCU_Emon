# Repository whatnick/NodeMCU_Emon

## EAGLE design NodeMCU_Emon.brd

Parts:
B2: MB8S; SOIC-4
C1: 100uF; 175TMP-0808
C2: 10uF; 153CLV-0405
J1, J2, J13, J14: HEADER-15P'2.54'; H15-2.54
J3: 10p-2.54; H10-2.54
J4: CON_DC_M-DC_SMD; DC_BARREL_JACK_SMD_2MM
J6: ST-PJ-312; AUDIO6P-SMD-3.5-14.0X6.4X5.0MM
J7: H4P-SMD-2.0; HW4-SMD-2.0
PWR: GREEN; LED-0603
R1: 1k; R0603
R2: 100K; R0603
R3, R5: 10K; R0603
R4: 100R; R0603
U1: SR05

Connections:
3V3: J1.11, J2.6, J2.15, J3.1, J7.3, J13.11, J14.6, J14.15, R1.1
A0: J1.1, J13.1
A2: J3.9, R5.1
ADDR: J3.5
CLK: J1.9, J13.9
CMD: J1.7, J13.7
D0: J2.1, J14.1
D1: J2.2, J3.3, J7.1, J14.2
D2: J2.3, J3.4, J7.2, J14.3
D3: J2.4, J14.4
D4: J2.5, J14.5
D5: J2.8, J14.8
D6: J2.9, J14.9
D7: J2.10, J14.10
D8: J2.11, J14.11
D9: J2.12, J14.12
D10: J2.13, J14.13
EN: J1.12, J13.12
GND: B2.-, C1.-, C2.-, J1.10, J1.14, J2.7, J2.14, J3.2, J7.4, J7.SS1, J7.SS2, J13.10, J13.14, J14.7, J14.14, PWR.-, U1.P$2 (GND)
I_AC+: J3.7, J6.COM1, R4.2
I_AC-: J3.8, J6.L, R4.1
unnamed: PWR.+, R1.2
unnamed: B2.~1 (AC1), J4.P2, R2.1
unnamed: B2.+, C1.+, U1.P$1 (IN)
NC: J3.6
RST: J1.13, J13.13
RSV: J1.2, J13.2
RSVV: J1.3, J13.3
SD0: J1.8, J13.8
SD1: J1.6, J13.6
SD2: J1.5, J13.5
SD3: J1.4, J13.4
VIN: C2.+, J1.15, J13.15, U1.P$3 (OUT)
V_AC+: J3.10, R2.2, R3.1
V_AC-: B2.~2 (AC2), J4.P1@2 (P1), R3.2, R5.2

Notes on the sheet:
Tisham Dhar

Board: 2 copper layers, 70.8 x 44.8 mm, 20 parts (2 on the bottom side), 33 nets.

Other parts of the board:
U$27: OSHW_FILLX200_NOTEXT
U$29: SEEED-SILK-280*268MIL

## Commit log

2015-09-14 Moved boundaries
2015-09-29 Added extra resistor to protect ADC
2015-10-11 Switching to SMD
2015-10-13 Addded SMD jack and routing, polarity wrong
2015-10-13 Routed fixed rectifier polarity
2015-10-13 Routed
2015-10-13 Small curve changes
2015-10-15 Finished routing and fixups
2015-10-15 Changed values
2015-10-17 Changed to XP Power SR05 footprint
2015-10-17 Moved power LED for simpler routing
2015-10-17 Text changes
2015-11-13 Added keepout

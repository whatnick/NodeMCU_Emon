File: NodeMCU_Emon.brd (EAGLE design)
At the start: 67.6 x 44.8 mm, 20 parts, among them IC1-D24V5F5 7805T, J3 10p-2.54, J6 ST-PJ-312, J7 H4P-SMD-2.0

Commit message: Finished routing and fixups
Parts:
- C1: value 10uF -> 100uF; device adafruit:153CLV-0405 -> adafruit:175TMP-0808
- C2: value 100uF -> 10uF; device adafruit:175TMP-0808 -> adafruit:153CLV-0405
- R4: value 330R -> 100R
- moved R2 18.3 mm to (49.6, 17.5)
- moved B2 17.4 mm to (53.3, 11.0), turned to 90 degrees
- moved R3 9.09 mm to (51.7, 17.5)
- moved J4 7.20 mm to (62.5, 22.0)
- moved J7 6.11 mm to (60.6, 7.75), turned to 270 degrees
- moved R5 6.02 mm to (50.7, 20.3), turned to 0 degrees
- moved PWR 5.30 mm to (53.6, 19.7), turned to 90 degrees
- moved R1 4.24 mm to (53.6, 25.0)
- moved J3 1.71 mm to (51.6, 41.8)
- moved IC1-D24V5F5 1.53 mm to (45.0, 31.6)
- moved R4 1.27 mm to (55.5, 34.4)
- moved C1 1.27 mm to (45.0, 6.86), turned to 180 degrees
- moved J6 0.89 mm to (70.9, 34.5)
Connections:
- net I_AC+: now also J6.COM1; no longer J6.R
- net I_AC-: now also J6.L; no longer J6.COM2
Routing:
- net N$3: track 9.16 -> 33.3 mm
- net N$4: track 40.0 -> 22.7 mm, vias 1 -> 0
- net VIN: track 57.3 -> 73.9 mm
- net I_AC-: track 29.4 -> 17.2 mm, vias 1 -> 0
- net A2: track 17.4 -> 25.9 mm
- net 3V3: track 134.4 -> 127.1 mm, vias 1 -> 0
- net V_AC+: track 24.9 -> 31.8 mm
- net N$1: track 13.4 -> 7.54 mm
- net V_AC-: track 28.1 -> 33.1 mm, vias 2 -> 3
- net I_AC+: track 16.4 -> 21.3 mm
- net D2: track 57.6 -> 61.1 mm
- net GND: track 2.11 -> 0.00 mm, vias 13 -> 15
- net D1: track 55.0 -> 55.7 mm, vias 0 -> 1

Commit message: Changed to XP Power SR05 footprint
Parts:
- removed IC1-D24V5F5: 7805T, adafruit:TO220H
- added U1: SR05, Seeed-OPL-ic:SR05
- moved C1 26.2 mm to (44.7, 33.0), turned to 270 degrees
- moved R5 13.0 mm to (52.7, 33.1)
- moved R2 11.6 mm to (51.5, 29.0)
- moved R3 11.6 mm to (53.6, 29.0), turned to 90 degrees
- moved C2 2.90 mm to (45.3, 11.6), turned to 270 degrees
- moved B2 0.99 mm to (52.7, 11.8)
- moved PWR 0.25 mm to (53.6, 19.4), turned to 270 degrees
- turned R1 to 0 degrees
Connections:
- net GND: now also U1.P$2; no longer IC1-D24V5F5.2
- net N$4: now also U1.P$1; no longer IC1-D24V5F5.1
- net VIN: now also U1.P$3; no longer IC1-D24V5F5.3
Routing:
- net VIN: track 73.9 -> 52.2 mm
- net A2: track 25.9 -> 12.4 mm
- net I_AC-: track 17.2 -> 27.7 mm
- net D2: track 61.1 -> 54.3 mm, vias 0 -> 1
- net V_AC+: track 31.8 -> 25.3 mm
- net I_AC+: track 21.3 -> 27.3 mm
- net N$4: track 22.7 -> 18.8 mm
- net N$1: track 7.54 -> 4.09 mm
- net D1: track 55.7 -> 57.4 mm, vias 1 -> 0
- net V_AC-: track 33.1 -> 31.4 mm, vias 3 -> 0
- net GND: track 0.00 -> 1.00 mm, vias 15 -> 18
- net 3V3: track 127.1 -> 126.7 mm, vias 0 -> 3
- net N$3: vias 0 -> 2

Commit message: Moved power LED for simpler routing
Parts:
- moved R1 22.6 mm to (50.3, 2.67), turned to 90 degrees
- moved PWR 15.3 mm to (50.3, 4.45), turned to 0 degrees
Routing:
- net 3V3: track 126.7 -> 121.2 mm, vias 3 -> 2
- net N$1: track 4.09 -> 0.25 mm
Changed lines of the file:
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@@
 <layer number="21" name="tPlace" color="7" fill="1" visible="yes" active="yes"/>
 <layer number="22" name="bPlace" color="3" fill="1" visible="yes" active="yes"/>
-<layer number="23" name="tOrigins" color="15" fill="1" visible="no" active="yes"/>
-<layer number="24" name="bOrigins" color="3" fill="1" visible="no" active="yes"/>
+<layer number="23" name="tOrigins" color="15" fill="1" visible="yes" active="yes"/>
+<layer number="24" name="bOrigins" color="3" fill="1" visible="yes" active="yes"/>
 <layer number="25" name="tNames" color="7" fill="1" visible="yes" active="yes"/>
 <layer number="26" name="bNames" color="3" fill="1" visible="yes" active="yes"/>
@@
 <attribute name="NAME" x="18.6182" y="22.5552" size="0.254" layer="33" ratio="10" rot="R180"/>
 </element>
-<element name="PWR" library="Discrete-new" package="LED-0603" value="GREEN" x="53.594" y="19.431" smashed="yes" rot="R270">
-<attribute name="NAME" x="53.975" y="21.082" size="0.889" layer="25" ratio="11" rot="R90"/>
-<attribute name="VALUE" x="51.8795" y="21.336" size="0.889" layer="27" ratio="11" rot="R270"/>
-</element>
-<element name="R1" library="Discrete-new" package="R0603" value="1k" x="53.594" y="25.019" smashed="yes">
-<attribute name="NAME" x="53.086" y="28.702" size="1.016" layer="25" ratio="11" rot="R270"/>
-<attribute name="VALUE" x="54.229" y="23.114" size="0.635" layer="27" ratio="10" rot="R90"/>
+<element name="PWR" library="Discrete-new" package="LED-0603" value="GREEN" x="50.292" y="4.445" smashed="yes">
+<attribute name="NAME" x="48.641" y="4.826" size="0.889" layer="25" ratio="11" rot="R180"/>
+<attribute name="VALUE" x="48.387" y="2.7305" size="0.889" layer="27" ratio="11"/>
+</element>
+<element name="R1" library="Discrete-new" package="R0603" value="1k" x="50.292" y="2.667" smashed="yes" rot="R90">
+<attribute name="NAME" x="46.609" y="2.159" size="1.016" layer="25" ratio="11"/>
+<attribute name="VALUE" x="52.197" y="3.302" size="0.635" layer="27" ratio="10" rot="R180"/>
 </element>
 <element name="U$27" library="Logo" package="OSHW_FILLX200_NOTEXT" value="" x="21.59" y="10.795" rot="MR90"/>
@@
 <contactref element="J7" pad="SS2"/>
 <contactref element="U1" pad="P$2"/>
-<wire x1="53.6575" y1="18.7325" x2="53.594" y2="18.669" width="0.8128" layer="1"/>
-<wire x1="53.6575" y1="18.7325" x2="53.59398125" y2="18.668965625" width="0.8128" layer="1"/>
 <wire x1="9.525" y1="6.985" x2="9.525" y2="7.23898125" width="0.8128" layer="1"/>
 <wire x1="9.525" y1="6.985" x2="9.017" y2="7.239" width="0.8128" layer="1"/>
@@
 <wire x1="9.3726" y1="14.7066" x2="9.017" y2="14.859" width="0.8128" layer="1"/>
 <wire x1="31.5468" y1="4.953" x2="31.877" y2="4.699" width="0.8128" layer="1"/>
-<wire x1="43.815" y1="6.6675" x2="48.006" y2="6.6675" width="0.8128" layer="1"/>
-<wire x1="48.006" y1="6.6675" x2="60.325" y2="6.6675" width="0.8128" layer="1"/>
+<wire x1="43.815" y1="6.6675" x2="48.1584" y2="6.6675" width="0.8128" layer="1"/>
+<wire x1="48.1584" y1="6.6675" x2="60.325" y2="6.6675" width="0.8128" layer="1"/>
 <wire x1="41.91" y1="4.7625" x2="43.815" y2="6.6675" width="0.8128" layer="16"/>
 <wire x1="34.6075" y1="4.7625" x2="41.91" y2="4.7625" width="0.8128" layer="16"/>
@@
 <wire x1="31.75" y1="27.305" x2="31.877" y2="27.559" width="0.8128" layer="1"/>
 <wire x1="21.9075" y1="14.9225" x2="21.7932" y2="14.7066" width="0.8128" layer="1"/>
-<via x="43.815" y="6.6675" extent="1-16" drill="0.3048"/>
-<wire x1="50.927" y1="20.066" x2="52.324" y2="21.463" width="0.8128" layer="16"/>
-<wire x1="48.133" y1="20.066" x2="50.927" y2="20.066" width="0.8128" layer="16"/>
-<wire x1="48.133" y1="17.272" x2="48.133" y2="20.066" width="0.8128" layer="1"/>
-<wire x1="48.006" y1="17.145" x2="48.133" y2="17.272" width="0.8128" layer="1"/>
-<wire x1="48.006" y1="6.6675" x2="48.006" y2="17.145" width="0.8128" layer="1"/>
+<wire x1="43.815" y1="6.6675" x2="43.815" y2="6.6675" width="0" layer="19" extent="1-16"/>
 <via x="52.324" y="21.463" extent="1-16" drill="0.3302" diameter="0.4064"/>
 <via x="48.133" y="20.066" extent="1-16" drill="0.3302" diameter="0.4064"/>
-<wire x1="52.324" y1="21.463" x2="52.324" y2="24.638" width="0.8128" layer="1"/>
-<wire x1="52.3875" y1="25.7175" x2="53.34" y2="25.7175" width="0.8128" layer="1"/>
-<wire x1="52.3875" y1="24.765" x2="52.3875" y2="25.7175" width="0.8128" layer="1"/>
-<wire x1="53.34" y1="25.7175" x2="53.594" y2="25.781" width="0.8128" layer="1"/>
-<wire x1="52.3875" y1="24.765" x2="52.324" y2="24.638" width="0.8128" layer="1"/>
+<wire x1="50.9778" y1="20.1168" x2="48.1584" y2="20.1168" width="0.8128" layer="16"/>
+<wire x1="52.324" y1="21.463" x2="50.9778" y2="20.1168" width="0.8128" layer="16"/>
+<wire x1="48.1584" y1="20.1168" x2="48.133" y2="20.066" width="0.8128" layer="16"/>
+<wire x1="48.6156" y1="3.5814" x2="49.53" y2="2.667" width="0" layer="19" extent="1-16"/>
+<wire x1="47.0916" y1="3.5814" x2="48.6156" y2="3.5814" width="0" layer="19" extent="1-16"/>
+<wire x1="44.196" y1="6.477" x2="47.0916" y2="3.5814" width="0" layer="19" extent="1-16"/>
+<wire x1="44.196" y1="6.477" x2="43.815" y2="6.6675" width="0" layer="19" extent="1-16"/>
+<wire x1="48.1584" y1="6.6675" x2="48.1584" y2="20.0406" width="0.8128" layer="1"/>
+<wire x1="48.1584" y1="20.0406" x2="48.133" y2="20.066" width="0.8128" layer="1"/>
+<wire x1="48.6156" y1="3.5814" x2="48.6156" y2="3.5814" width="0" layer="19" extent="1-16"/>
 </signal>
 <signal name="RST">
@@
 <contactref element="PWR" pad="+"/>
 <contactref element="R1" pad="2"/>
-<wire x1="53.6575" y1="24.13" x2="53.6575" y2="20.32" width="0.1524" layer="1"/>
-<wire x1="53.6575" y1="20.32" x2="53.594" y2="20.193" width="0.1524" layer="1"/>
-<wire x1="53.6575" y1="24.13" x2="53.594" y2="24.257" width="0.1524" layer="1"/>
+<wire x1="51.054" y1="2.8956" x2="51.054" y2="2.667" width="0.1524" layer="1"/>
+<wire x1="49.53" y1="4.4196" x2="51.054" y2="2.8956" width="0" layer="19" extent="1-16"/>
+<wire x1="49.53" y1="4.4196" x2="49.53" y2="4.445" width="0.1524" layer="1"/>
 </signal>
 <signal name="V_AC-" class="1">
